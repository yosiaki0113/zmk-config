## config/boards/shields/xiao_macro/Kconfig.defconfig
```kconfig
if SHIELD_XIAO_MACRO

config ZMK_KEYBOARD_NAME
    default "ArmRayker"

config ADC
    default y

endif
```
